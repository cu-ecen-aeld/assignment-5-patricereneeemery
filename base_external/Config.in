## base_external/Config.in
```kconfig
menu "AESD assignments"

source "$BR2_EXTERNAL_BASE_EXTERNAL_PATH/package/Config.in"

endmenu
```
